# Keil uVision project Heart-rate-monitor-and-oximeter.uvprojx, settings and files
target Target 1 (6180000::V6.18::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c switch.c lcd.c DAC.c ADC.c Buzz.c SPI.c LED.c RGB_Bar.c segments.c i2c.c MPU_stuff.c usart.c timer.c PeakDetection.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
